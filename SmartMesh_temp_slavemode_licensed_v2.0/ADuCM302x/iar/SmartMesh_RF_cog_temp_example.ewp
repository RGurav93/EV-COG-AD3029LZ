# IAR project SmartMesh_RF_cog_temp_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM3029__
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SmartMesh_RF_cog_temp_example.hex
  ILINK.IlinkOutputFile: SmartMesh_RF_cog_temp_example.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM3029__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: uart_loopback.out
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/i2c/: adi_i2c.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/uart/: adi_uart.c
    ../../../../../Source/drivers/wdt/: adi_wdt.c
  group SmartMesh_Clibrary
    ../../clib/: dn_endianness.c dn_hdlc.c dn_ipmt.c dn_lock.c dn_serial_mt.c
  group Source
    ../../: dn_uart_handle.c SmartMesh_RF_cog_temp_example.c
  group System
    ../../../../../Source/: common.c system_ADuCM3029.c
    ../: PinMux.c
    ../../../../../Source/IAR/: startup_ADuCM3029.s
