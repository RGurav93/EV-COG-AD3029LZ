# IAR project sd_card_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __ADUCM3029__
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\Include\config; libs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Analog Devices\ADuCM302x\ADuCM302x_EZ_Kit\Include\config; C:\Analog Devices\ADuCM302x\ADuCM302x_EZ_Kit\Include
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../Source/: common.c
    ./: main.c PinMux.c
  group ADR7420_temp_log
    libs/ADT7420/: ADT7420.c
  group drivers
    ../../Source/drivers/dma/: adi_dma.c
    ../../Source/drivers/gpio/: adi_gpio.c
    ../../Source/drivers/i2c/: adi_i2c.c
    ../../Source/drivers/pwr/: adi_pwr.c
    ../../Source/drivers/rtc/: adi_rtc.c
    ../../Source/drivers/spi/: adi_spi.c
    ../../Source/drivers/uart/: adi_uart.c
    ../../Source/drivers/wdt/: adi_wdt.c
  group FSFAT
    libs/fsfat/: diskio.c ff.c
  group HAL
    libs/hal/: sd.c sdcard_spi_hal.c
  group RTC_timestamp
    libs/rtc_timestamp/: time_stamp.c
  group System Files
    ../../Source/IAR/: startup_ADuCM3029.s
    ../../Source/: system_ADuCM3029.c
